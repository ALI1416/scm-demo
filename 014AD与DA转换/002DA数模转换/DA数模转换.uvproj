# Keil uVision project DA数模转换.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DA数模转换 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DELAY.c DELAY.H TIMER0.c TIMER0.h

# Keil uVision project 可调.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 可调 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.H DS1302.c DS1302.H DELAY.c DELAY.H Key.c Key.h TIMER0.c TIMER0.h

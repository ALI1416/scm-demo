# Keil uVision project 秒表.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 秒表 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Nixie.c Nixie.H I2C.c I2C.H AT24C02.c AT24C02.H DELAY.c DELAY.H Key.c Key.h TIMER0.c TIMER0.h

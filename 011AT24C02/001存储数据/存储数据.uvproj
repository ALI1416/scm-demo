# Keil uVision project 存储数据.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 存储数据 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.H I2C.c I2C.H AT24C02.c AT24C02.H DELAY.c DELAY.H Key.c Key.h

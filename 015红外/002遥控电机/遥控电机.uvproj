# Keil uVision project 遥控电机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 遥控电机 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c IR.c IR.H Key.c Key.H Int0.c Int0.H Timer0.c Timer0.H Timer1.c Timer1.H NIXIE.H NIXIE.c Motor.c Motor.H DELAY.c DELAY.H

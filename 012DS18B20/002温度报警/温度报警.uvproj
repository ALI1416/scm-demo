# Keil uVision project 温度报警.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温度报警 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.H OneWire.c OneWire.H DS18B20.c DS18B20.H DELAY.c DELAY.H AT24C02.c AT24C02.H I2C.c I2C.H Key.c Key.H TIMER0.c TIMER0.H

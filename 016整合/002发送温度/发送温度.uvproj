# Keil uVision project 发送温度.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 发送温度 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c UART.c UART.h TIMER0.c TIMER0.h LCD1602.c LCD1602.H OneWire.c OneWire.H DS18B20.c DS18B20.H
